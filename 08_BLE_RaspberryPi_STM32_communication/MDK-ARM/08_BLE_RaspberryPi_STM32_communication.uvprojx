# Keil uVision project 08_BLE_RaspberryPi_STM32_communication.uvprojx, settings and files
target 08_BLE_RaspberryPi_STM32_communication (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: 08_BLE_RaspberryPi_STM32_communication +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic;../Middlewares/ST/BlueNRG-MS/includes;../Middlewares/ST/BlueNRG-MS/utils;../Middlewares/ST/Middlewares/ST/BlueNRG-MS/includes;../Middlewares/ST/Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Template;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User
    ../Src/: main.c gpio.c hci_tl_interface.c usart.c custom_bus.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4_nucleo_f401re.c
    ./: app_x-cube-ble1.c app_x-cube-ble1.h services.c services.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/BlueNRG-MS/Wireless/HCI_TL/Basic
    ../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/BlueNRG-MS/Wireless/Controller
    ../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_IFR.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/Wireless/Utils
    ../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
software components: CMSIS:CORE 5.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
